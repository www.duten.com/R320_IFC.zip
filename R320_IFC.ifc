Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-04-16T12:38:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 16 12:38:11 2021 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{FF84CA04-2AD8-4B2D-830F-F0A81056D01A}\ifc * Database version: 5507 * Database creation date: Fri Apr 16 12:38:10 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 16 12:38:10 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 16 12:38:10 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowController: Battery Operated Brushed Stainless Steel, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R320:Battery Operated Brushed Stainless Steel:320637
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_BrushedStainlessSteel, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Recessed Installation Battery Operated Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Battery Operated Matte Black, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R320:Battery Operated Matte Black:324618
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_MatteBlack, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Recessed Installation Battery Operated Matte Black; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Battery Operated Polished Brass, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R320:Battery Operated Polished Brass:324635
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Recessed Installation Battery Operated Polished Brass; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Brushed Stainless Steel, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R320:Mains Operated Brushed Stainless Steel:324667
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_BrushedStainlessSteel, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Recessed Installation Mains Operated Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Matte Black, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R320:Mains Operated Matte Black:324669
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_MatteBlack, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Recessed Installation Mains Operated Matte Black; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Polished Brass, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R320:Mains Operated Polished Brass:324670
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_Chrome
Pset_ManufacturerTypeInformation - ModelReference: Recessed Installation Mains Operated Polished Brass; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a
